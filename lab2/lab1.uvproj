# Keil uVision project lab1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MB9BF568N Spansion
  cpu: IRAM(0x20038000-0x20047FFF) IRAM2(0x1FFF0000-0x1FFFFFFF) IROM(0x00000000-0x000FFFFF) IROM2(0x200C0000-0x200C7FFF) CLOCK(4000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab1
  c flags: Optim=1
  c include: .\common;.\lib\inc;.\WyzBee_SPI;.\WyzBee_oled;.\WyzBee_gpio;.\WyzBee_i2c
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x20038000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: startup_mb9bf56x.s system_mb9abxxx.c
    ./lib/src/: exint.c mfs.c mfs_hl.c clk.c reset.c
    ./common/: interrupts.c pdl.c
    ./WyzBee_gpio/: WyzBee_gpio.c
  group App
    ./: main.cpp
  group WyzBee_spi
    ./WyzBee_SPI/: WyzBee_spi.c
  group WyzBee_oled
    ./WyzBee_oled/: Adafruit_SSD1351.cpp Adafruit_SSD1351.h binary.h glcdfont.c license.txt pgmspace.h README.txt SPI_OLED.cpp SPI_OLED.h Adafruit_GFX.cpp Adafruit_GFX.h
  group WyzBee_i2c
    ./WyzBee_i2c/: WyzBee_i2c.c
  group WyzBee_ext
    ./WyzBee_ext/: WyzBee_ext.c
