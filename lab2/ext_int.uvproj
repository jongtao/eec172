# Keil uVision project ext_int.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MB9BF568N Spansion
  cpu: IRAM(0x20038000-0x20047FFF) IRAM2(0x1FFF0000-0x1FFFFFFF) IROM(0x00000000-0x000FFFFF) IROM2(0x200C0000-0x200C7FFF) CLOCK(4000000) CPUTYPE("Cortex-M4") FPU2
  output: ext_int
  c flags: Optim=1
  c include: .\common;.\lib\inc;.\WyzBee_ext;.\WyzBee_gpio
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x20038000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: startup_mb9bf56x.s system_mb9abxxx.c main.cpp infrared.c game.cpp
    ./common/: pdl.c interrupts.c mcu.h pdl.h pdl_user.h
    ./lib/src/: exint.c dt.c clk.c mfs.c reset.c
    ./WyzBee_timer/: WyzBee_timer.c WyzBee_timer.h
    ./lib/inc/: dt.h clk.h mfs.h reset.h
    ./WyzBee_gpio/: WyzBee_gpio.c WyzBee_gpio.h chip.h timetick.c timetick.h variant.cpp variant.h wiring.c wiring.h WyzBee.h Wyzbee_kit.h
    ./WyzBee_ext/: WyzBee_ext.h
    ./WyzBee_oled/: Adafruit_GFX.cpp Adafruit_GFX.h Adafruit_SSD1351.cpp Adafruit_SSD1351.h binary.h glcdfont.c license.txt pgmspace.h README.txt SPI_OLED.cpp SPI_OLED.h
    ./WyzBee_SPI/: WyzBee_spi.c WyzBee_spi.h
  group WyzBee_ext
    ./WyzBee_ext/: WyzBee_ext.c
