# Keil uVision project WyzBee_BT_App.uvproj, settings and files
target BT_Master (ARM-ADS)
  device: MB9BF568N Spansion
  cpu: IRAM(0x20038000-0x20047FFF) IRAM2(0x1FFF0000-0x1FFFFFFF) IROM(0x00000000-0x000FFFFF) IROM2(0x200C0000-0x200C7FFF) CLOCK(4000000) CPUTYPE("Cortex-M4") FPU2
  output: WyzBee_BT_App
  c flags: Optim=1
  c include: ..\common;..\Lib\BSP;..\Lib\BSP\driver;..\Lib\IR_Library\inc;..\Lib\rsi_bt_apis\core\include;..\Lib\rsi_wifi_apis\ref_apps\include;..\Lib\rsi_wifi_apis\hal\include;..\Lib\rsi_wifi_apis\hal\SPI;..\Lib\rsi_wifi_apis\intf\spi\include;..\Lib\WyzBee_oled;..\Lib\WyzBee_SPI;..\Lib\BSP\driver\dt;..\Lib\BSP\driver\gpio;..\Lib\BSP\driver\mfs;..\Lib\rsi_wifi_apis\core\include;..\Lib\rsi_bt_apis\ref_apps\include;..\Lib\BSP\driver\exint;..\Lib\WyzBee_BT;..\Lib\WyzBee_gpio;..\Lib\WyzBee_timer;..\Lib\WyzBee_ext
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x20038000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group common
    ./: startup_mb9bf56x.s
    ../common/: system_mb9abxxx.c
  group App
    ../App/: main.cpp infrared.c game.cpp
  group boot_params
    ../Lib/rsi_wifi_apis/core/src/: rsi_execute_cmd.c rsi_bootup_config.c rsi_build_frame_descriptor.c rsi_send_boot_insn.c rsi_sys_init.c
  group BT_EDR
    ../Lib/rsi_bt_apis/core/src/: rsi_bt_api.c rsi_bt_build_frame_descriptor.c rsi_bt_core.c rsi_bt_execute_cmd.c rsi_bt_generic.c rsi_bt_spp.c
    ../Lib/rsi_bt_apis/ref_apps/src/: bt_main.c
  group OLED
    ../Lib/WyzBee_oled/: Adafruit_GFX.cpp Adafruit_SSD1351.cpp SPI_OLED.cpp
    ../Lib/WyzBee_SPI/: WyzBee_spi.c
  group BSP
    ../Lib/BSP/driver/: interrupts.c pdl.c variant.c delay.c timetick.c rsi_lib_util.c rsi_app_util.c
    ../Lib/BSP/driver/exint/: exint.c
    ../Lib/BSP/driver/dt/: dt.c
    ../Lib/BSP/driver/mfs/: mfs.c
  group HAL
    ../Lib/rsi_wifi_apis/hal/src/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_spi.c rsi_hal_mcu_timers.c
    ../Lib/rsi_wifi_apis/hal/SPI/: spi.c
    ../Lib/rsi_wifi_apis/intf/spi/src/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group WyzBee_BT
    ../Lib/WyzBee_BT/: wyzbee_bt.c
  group WyzBee_gpio
    ../Lib/WyzBee_gpio/: WyzBee.h WyzBee_gpio.c WyzBee_gpio.h Wyzbee_kit.h
  group WyzBee_ext
    ../Lib/WyzBee_ext/: WyzBee_ext.c
